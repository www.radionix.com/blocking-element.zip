Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Projektnummer
Time: 2023-06-21T15:56:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 15:56:02 2023 * Host: LIS-C-001FN * Database: C:\Users\ROG2OVR\AppData\Local\Temp\{2712895C-E2EC-44AD-AE0E-05E5B0005E78}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 15:56:00 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 15:56:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 15:56:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcBuildingElementProxy: Blocking element, Intrusion-Products_Bosch_Blocking element:Blocking_Element_Surface_Mount:392660
In: Ebene 0
Type - PredefinedType: USERDEFINED; Classification: Pr_75_30_30_03 Access control units (Uniclass 2015); Material: RAL 9002
Type - Constraints - Default Elevation: 1.3 m
Type - Dimensions - 2DSymbolOffset: 0.002 m; Dimension depth (mm): 16; Dimension height (mm): 28; Dimension width (mm): 118
Type - General - Break force for emercency opening (kN): 0.8 - 1 kN; IP Class: IP44; Max. distance bolts to locking plate: 4; Operating temperature (°C) (maximum): 55; Operating temperature (°C) (minimum): -25
Type - Identity Data - CTN: 4998149110; Description: Blocking element surface mount; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SPE_Blocking_Element_Installation_Manual_enUS_1434315531.pdf; Manufacturer: Bosch Security and Safety Systems; Material number: 4.998.149.110; OmniClass Number: 23.85.30.11.24; OmniClass Title: Micro-Switch Contacts for Doors and Windows; PlanningTools: NA; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/Blocking_Element_Data_sheet_deDE_1434485259.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/Blocking-element/p/4.998.149.110/; Type Name: Blocking_Element_Surface_Mount
Type - Materials and Finishes - Color in RAL: RAL 9002; Material: ABS
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Blocking element
Pset_BuildingElementProxyCommon - Reference: Blocking_Element_Surface_Mount; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Dimensions - Volume: 0.0000574991 m3
Identity Data - Mark: 1
Other - 2D_FlippedPosition: yes; 2D_OriginalPosition: no; Family: Intrusion-Products_Bosch_Blocking element: Blocking_Element_Surface_Mount; Family and Type: Intrusion-Products_Bosch_Blocking element: Blocking_Element_Surface_Mount; Schedule Level: Level: Ebene 0; Type: Intrusion-Products_Bosch_Blocking element: Blocking_Element_Surface_Mount; Type Id: Intrusion-Products_Bosch_Blocking element: Blocking_Element_Surface_Mount
Phasing - Phase Created: Phase 1
